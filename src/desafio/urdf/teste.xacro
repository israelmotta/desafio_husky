Commit message: .

File: src/desafio/urdf/teste.xacro (robot description, xacro)
@@ -57,5 +57,5 @@
     <parent link="top_plate_link" />
     <child link="base_camera" />
-    <origin xyz="0.12 0 0.05" rpy="0 0 0" />
+    <origin xyz="0 0 0.22" rpy="0 0 0" />
 </joint>
 </robot>
